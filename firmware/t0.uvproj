# Keil uVision project t0.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH551 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0xFF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: t0 +hex
  c flags: Optimize=8
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: STARTUP.A51 GPIO.C Main.C CH552.INC Debug.C
